Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 08121f5d-4202-4230-8766-604ec2ceb9dd, NumberOfSaves: 70], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Screw_SCIA2_4545.ifc
Time: 2026-06-29T15:45:04
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMechanicalFastener: Structural Connections : ROTHOB_Rothoblaas_Screw_SCIA2 : SCI4545_4.5x45mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_StainlessSteel_A2_CRC-II
Type - Data - AtmosphericCorrosivity: C1 | C2 | C3 | C4; ServiceClass: SC1 | SC2 | SC3; WoodCorrosivity: T1 | T2 | T3
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Screw_SCIA2; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23.20.40.11.14.24; OmniClassTitle: Screws; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/screws/screws-outdoor/sci-a2-aisi304; Revision: 000; UniClass2015Code: Pr_20_29_76_75; UniClass2015Title: Self-tapping screws; UniClass2015Version: Products v1.42; Version: 001
Type - Constraints - Default Elevation: 0 mm; ProductCode: 4545; ProductCodeL: 45 mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteel_A2_CRC-II
Type - Dimensions - 1stMemberMaxFasteningThickness_A: 15 mm; HeadAngle: 90 deg; HeadDiameter_dk: 9 mm; HeadHeight_t1: 4.25 mm; Length_L: 45 mm; NominalDiameter_d1: 4.5 mm; Pre-drillingHoleDiameter_dv: 3 mm; ShankDiameter_ds: 3.15 mm; ThreadDiameter_d2: 2.8 mm; ThreadLength_b: 30 mm; TipLength: 5.56 mm; UnderHeadDiameter: 4.13 mm
Type - Identity Data - Description: Countersunk screw; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.20.40.11.14.24; OmniClass Title: Screws; Type Name: SCI4545_4.5x45mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: Fixed; CECode: EN 14592; CETitle: Self-tapping screw to be used for structural connections in timber constructions according to EN14592; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Screw_SCIA2; Features: Superior strength and A2 austenitic stainless steel; Finish: Stainless steel; Grade: n/a; GTIN: 8033564760327; Material: A2 | AISI304 austenitic stainless steel; MinWeight: 0.003 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: SCI4545; ModelReference: n/a; Name: Screw; NominalDiameter: 4.5 mm; NominalHeight: n/a; NominalLength: 45 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 4.5x45 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Screw
Pset_QuantityTakeOff - Reference: SCI4545_4.5x45mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Area: 0.000259742 m2; Volume: 3.76096e-07 m3
Other - Family: ROTHOB_Rothoblaas_Screw_SCIA2; Family and Type: ROTHOB_Rothoblaas_Screw_SCIA2: SCI4545_4.5x45mm; InstallationDate: n/a; Type: SCI4545_4.5x45mm; Type Id: 2085329; WarrantyStartDate: n/a
